Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-26T14:44:57+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 57752483(2023):57752483 Cover part for bath and shower faucet, 75x75 mm, 57752483(2023):57752483 Cover part for bath and shower faucet, 75x75 mm:500863
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 241 mm; NominalHeight: 175 mm; NominalWidth: 435 mm
Type - General - Author: BIMStone; BIMObjectName: 57752483(2023); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 2025/10/01
Type - Green Building Properties - CO2 Emissions (A1-A3): 42.2; CO2 Emissions (A4): 0.7; CO2 Emissions (B7): 2547.6; CO2 Emissions (C2): 0.04; CO2 Emissions (C3): 0.04; CO2 Emissions (C4): 0.55; CO2 Emissions (D): -13.05; EN Standard: EN 817, EN 1112, EN 1113; ETIM Class Number: EC010862 Bath mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/57752483; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/57752483; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/185746_57752483_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/57752483
Type - Identity Data - 3D View: https://static.hansa.com/3D/57752483; Catalog Drawing URL: http://static.hansa.com/catdrw/57752483; Category B2C: Bathtub & Shower; Dimension Drawing URL: http://static.hansa.com/dimdrw/57752483; FDV Document URL: http://www.hansa.com/datasheet/57752483/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/57752483; Group: Bath faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/57752483; Interactive AR View URL: https://static.hansa.com/AR/57752483; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/57752483; Model: 57752483 Cover part for bath and shower faucet, 75x75 mm; Name_en: 57752483 Cover part for bath and shower faucet, 75x75 mm; OmniClass Number: 23.31.11.00; OmniClass Title: Faucets; Product Code: 57752483; Product Family: HANSALOFT; Product Image URL: http://static.hansa.com/image/57752483; Product URL: http://static.hansa.com/57752483; Replacement to: 57752083;57752473; Spare-Part Information URL: http://static.hansa.com/sp/57752483; Technical DataSheet URL: http://www.hansa.com/datasheet/57752483/en; Type Name: 57752483 Cover part for bath and shower faucet, 75x75 mm; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Anti-twist hose connector; Aerator: Standard aerator; Backflow Prevention EN1717: EB; Concealed Parts: Square rosette; Flow Rate At 300kPa: 0.34 m3/s; Installation Type: Rim mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 80 C; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 4 hole; Shower Parts: Hand shower;Shower hose (1750 mm); Shower Spray: Intense - invigorating water stream; Shower Spray Number: 1 spray function; Spout Projection: 185 mm; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 57752483(2023); Features: Trim Kit;Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 57752483; Name: 57752483 Cover part for bath and shower faucet, 75x75 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 435x213x214mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 57752483; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 57752483 Cover part for bath and shower faucet, 75x75 mm; Category: Plumbing Fixtures
Type - Pset_ValveTypeCommon - FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 57752483 Cover part for bath and shower faucet, 75x75 mm; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 950 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.25474 m2; Volume: 0.0231844 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 57752483(2023); Family and Type: 57752483(2023): 57752483 Cover part for bath and shower faucet, 75x75 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 57752483 Cover part for bath and shower faucet, 75x75 mm; Type Id: 500847; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
